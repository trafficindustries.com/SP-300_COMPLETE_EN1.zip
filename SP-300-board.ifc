Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-09-24T21:32:25
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcBuildingElementProxy: GRP sign panel profile (3)
In: Local product coordinates
Description: Interpretation candidate *; not for fabrication; no material grade or mechanical certification assigned; PredefinedType: USERDEFINED
Pset_TI_Product - ProductCode: SP-300; Material: GRP; grade unspecified; NominalPitch_mm: 300; Depth_mm: 19; Length_mm: 1000; ParameterSHA256: 56a53778531966d8055c132a5652533c6fb66f3d7ac431f969b184cb54f87af9; Interpretations: I02/I04 *; confirm before fabrication
Name
SP300_1
SP300_2
SP300_3
